# Keil uVision project Project.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: adc.c buzzer.c cal.c dac.c delay.c dma.c i2c_ee.c key.c lcd.c relay.c set.c test.c usart.c stm32f10x_it.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rcc.c matrix.c ST3.C DEF.H normal.c
  group FWLib
    ./: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ./: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GI_600(TEST)_noh +hex
  c flags: Optim=3 wLevel=2
  c include: .\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
